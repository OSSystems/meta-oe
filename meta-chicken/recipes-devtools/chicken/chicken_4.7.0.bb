require chicken.inc

BBCLASSEXTEND = "native"

DEPENDS = "chicken-cross"
DEPENDS_virtclass-native = ""

PR = "${INC_PR}.0"
